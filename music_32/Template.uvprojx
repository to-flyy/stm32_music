# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Driver_HardWare\LED;.\Public\system;.\Public\SysTick;.\Public\Delay;.\Driver_HardWare\KEY;.\freertos;.\freertos\inc;.\freertos\port;.\freertos\src;.\Driver_HardWare\K210;.\Driver_HardWare\BuJin;.\Driver_HardWare\MP3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ./User/: main.c stm32f10x_it.c
  group Driver_HardWare
    ./Driver_HardWare/LED/: LED.c
    ./Driver_HardWare/KEY/: Key.c
    ./Driver_HardWare/K210/: K210.c
    ./Driver_HardWare/BuJin/: motor.c
    ./Driver_HardWare/MP3/: MP3.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group Public
    ./Public/system/: system.c
    ./Public/SysTick/: SysTick.c
    ./Public/Delay/: Delay.c
  group freertos/src
    ./freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/inc
    ./freertos/: FreeRTOSConfig.h
    ./freertos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/port
    ./freertos/port/: heap_4.c port.c
